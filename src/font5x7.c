#include "font5x7.h"
#include <stddef.h>

static const uint8_t glyph_blank[5] = {0x00, 0x00, 0x00, 0x00, 0x00};
static const uint8_t glyph_unknown[5] = {0x02, 0x01, 0x51, 0x09, 0x06};
static const uint8_t glyph_colon[5] = {0x00, 0x36, 0x36, 0x00, 0x00};
static const uint8_t glyph_dot[5] = {0x00, 0x60, 0x60, 0x00, 0x00};
static const uint8_t glyph_minus[5] = {0x08, 0x08, 0x08, 0x08, 0x08};

static const uint8_t digit_glyphs[10][5] = {
    {0x3E, 0x51, 0x49, 0x45, 0x3E},
    {0x00, 0x42, 0x7F, 0x40, 0x00},
    {0x42, 0x61, 0x51, 0x49, 0x46},
    {0x21, 0x41, 0x45, 0x4B, 0x31},
    {0x18, 0x14, 0x12, 0x7F, 0x10},
    {0x27, 0x45, 0x45, 0x45, 0x39},
    {0x3C, 0x4A, 0x49, 0x49, 0x30},
    {0x01, 0x71, 0x09, 0x05, 0x03},
    {0x36, 0x49, 0x49, 0x49, 0x36},
    {0x06, 0x49, 0x49, 0x29, 0x1E}
};

static const uint8_t uppercase_glyphs[26][5] = {
    {0x7E, 0x11, 0x11, 0x11, 0x7E},
    {0x7F, 0x49, 0x49, 0x49, 0x36},
    {0x3E, 0x41, 0x41, 0x41, 0x22},
    {0x7F, 0x41, 0x41, 0x22, 0x1C},
    {0x7F, 0x49, 0x49, 0x49, 0x41},
    {0x7F, 0x09, 0x09, 0x09, 0x01},
    {0x3E, 0x41, 0x49, 0x49, 0x7A},
    {0x7F, 0x08, 0x08, 0x08, 0x7F},
    {0x00, 0x41, 0x7F, 0x41, 0x00},
    {0x20, 0x40, 0x41, 0x3F, 0x01},
    {0x7F, 0x08, 0x14, 0x22, 0x41},
    {0x7F, 0x40, 0x40, 0x40, 0x40},
    {0x7F, 0x02, 0x0C, 0x02, 0x7F},
    {0x7F, 0x04, 0x08, 0x10, 0x7F},
    {0x3E, 0x41, 0x41, 0x41, 0x3E},
    {0x7F, 0x09, 0x09, 0x09, 0x06},
    {0x3E, 0x41, 0x51, 0x21, 0x5E},
    {0x7F, 0x09, 0x19, 0x29, 0x46},
    {0x46, 0x49, 0x49, 0x49, 0x31},
    {0x01, 0x01, 0x7F, 0x01, 0x01},
    {0x3F, 0x40, 0x40, 0x40, 0x3F},
    {0x1F, 0x20, 0x40, 0x20, 0x1F},
    {0x3F, 0x40, 0x38, 0x40, 0x3F},
    {0x63, 0x14, 0x08, 0x14, 0x63},
    {0x07, 0x08, 0x70, 0x08, 0x07},
    {0x61, 0x51, 0x49, 0x45, 0x43}
};

const uint8_t *Font5x7_GetGlyph(char character)
{
    if (character == ' ') {
        return glyph_blank;
    }
    if (character >= '0' && character <= '9') {
        return digit_glyphs[(uint8_t)(character - '0')];
    }
    if (character >= 'A' && character <= 'Z') {
        return uppercase_glyphs[(uint8_t)(character - 'A')];
    }

    switch (character) {
    case ':': return glyph_colon;
    case '.': return glyph_dot;
    case '-': return glyph_minus;
    default:  return glyph_unknown;
    }
}
